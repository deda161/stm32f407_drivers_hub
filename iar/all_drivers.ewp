# IAR project all_drivers.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx
  ICCARM.CCIncludePath2: ..\src; ..\src\core; ..\src\core\CMSIS; ..\src\core\CMSIS_CORE; ..\src\port; ..\src\gpio_driver; ..\src\rcc_driver; ..\src\usart_driver; ..\src\exti_driver
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: all_drivers.srec
  ILINK.IlinkOutputFile: all_drivers.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: main.c main.h
    ../src/port/: startup_stm32f407xx.s
  group core/CMSIS
    ../src/core/CMSIS/: system_stm32f4xx.c
  group exti
    ../src/exti_driver/: exti.c exti.h
  group gpio
    ../src/gpio_driver/: gpio.c gpio.h
  group rcc
    ../src/rcc_driver/: rcc.c rcc.h
  group usart
    ../src/usart_driver/: usart.c usart.h
